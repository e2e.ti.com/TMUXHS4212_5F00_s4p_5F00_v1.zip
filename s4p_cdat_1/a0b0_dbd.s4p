!Keysight Technologies,N5224B,MY58421843,A.13.80.08
!Date: Thursday, December 12, 2019 06:50:43
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 5.008 GHz, 10.01 GHz, 15 GHz, 20 GHz:
!     S43: -0.5, -1.6, -2.6, -5.6, -6.1
!     S21: -0.5, -1.8, -5.1, -5.2, -7.3
!     S32: -51.8, -16.2, -12.6, -13.0, -16.6
!     S41: -53.0, -16.4, -12.5, -13.8, -13.8
!     S42: -50.2, -15.2, -13.3, -17.1, -21.1
!     S31: -57.8, -19.8, -13.6, -18.7, -15.3
!   lowest |S11| = -29.8 dB at 1.884 GHz (marker M1), VSWR 1.07, Z = 51.7 - j2.83 ohm
!   |S11| at or under -10 dB: start of sweep to 7.572 GHz; 8.271 GHz to 8.417 GHz (145.6 MHz wide, 1.74 % of centre); 8.419 GHz to 8.526 GHz (107.2 MHz wide, 1.26 % of centre) (the widest 3 of 7)
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! magnitudes (dB):
! f  S11  S43  S21  S32  S41  S42  S31
! 10 MHz  -26.9  -0.5  -0.5  -51.8  -53.0  -50.2  -57.8
! 497.3 MHz  -25.0  -0.5  -0.6  -35.8  -36.0  -28.5  -28.6
! 1.884 GHz  -29.8  -0.7  -0.9  -25.3  -24.9  -18.6  -18.9
! 3.121 GHz  -21.2  -1.0  -1.2  -20.1  -20.6  -16.6  -17.2
! 6.282 GHz  -13.9  -1.9  -2.5  -13.3  -13.8  -15.7  -18.8
! 14.05 GHz  -1.7  -5.1  -6.5  -12.6  -14.7  -16.1  -17.1
! 20 GHz  3.3  -6.1  -7.3  -16.6  -13.8  -21.1  -15.3
